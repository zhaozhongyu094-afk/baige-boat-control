# Keil uVision project BoatPWM.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(11059200)
  output: BoatPWM +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c Protocol.c Protocol.h Motor.c Motor.h
